# Keil uVision project ASK.uvproj, settings and files
target Target 1 (MCS-51)
  device: SM89516A SyncMOS
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: ASK +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MAIN.C UART.C AT_PRC.c DELAY.C PWM3.C TIMER0.C DHT11.C
